options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: debug_smartnet
    output_language: python
    title: SmartNet Debug
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: sink_demod
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: Demod (Float)
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: sink_in
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: Input (Complex)
    type: complex
  states: {}
- name: sink_sym
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: Symbol Filter (Float)
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: src_demod
  id: blocks_file_source
  parameters:
    file: /Users/luke/Projects/TrunkRecorder/build/smartnet_debug_demod.float
    repeat: 'True'
    type: float
  states: {}
- name: src_in
  id: blocks_file_source
  parameters:
    file: /Users/luke/Projects/TrunkRecorder/build/smartnet_debug_in.cfile
    repeat: 'True'
    type: complex
  states: {}
- name: src_sym
  id: blocks_file_source
  parameters:
    file: /Users/luke/Projects/TrunkRecorder/build/smartnet_debug_sym.float
    repeat: 'True'
    type: float
  states: {state: disabled}
- name: throttle_demod
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: throttle_in
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: throttle_sym
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: disabled}

connections:
- [src_demod, '0', throttle_demod, '0']
- [src_in, '0', throttle_in, '0']
- [src_sym, '0', throttle_sym, '0']
- [throttle_demod, '0', sink_demod, '0']
- [throttle_in, '0', qtgui_waterfall_sink_x_0, '0']
- [throttle_in, '0', sink_in, '0']
- [throttle_sym, '0', sink_sym, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
